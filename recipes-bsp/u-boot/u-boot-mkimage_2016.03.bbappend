FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += "file://0001-Implement-SHA512-hash-and-sha512-rsa4096-signature-s.patch"
