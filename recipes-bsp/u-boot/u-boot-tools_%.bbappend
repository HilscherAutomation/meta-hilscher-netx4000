require uboot-update.inc
