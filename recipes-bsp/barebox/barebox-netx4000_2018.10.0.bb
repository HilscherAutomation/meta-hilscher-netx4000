require barebox.inc

BRANCH = "master"
SRCREV = "c854f79fd3b1c831cb583d2776a668dd260449e4"

DEPENDS += "lzop-native python-native"
