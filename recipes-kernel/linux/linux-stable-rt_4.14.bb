KBRANCH = "v4.14-netx4000-rt"
KTYPE = "preempt-rt"

# netX4000
LINUX_VERSION = "4.14.71-rt44"
SRCREV_machine="d5cc3b32be3e9c2bc65c85373cfd447ac5fbdb65"

SRCREV_meta="6a3254e7b370cbb86c1f73379dcf38885c1c69e0"

require linux-hilscher-common.inc
