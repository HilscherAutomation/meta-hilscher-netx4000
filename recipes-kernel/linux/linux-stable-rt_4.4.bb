KBRANCH = "v4.4-netx4000-rt"
KTYPE = "preempt-rt"

# netX4000
LINUX_VERSION = "4.4.174-rt178"
SRCREV_machine="a0b5ac852cd8cb9eaa46a168c18b09641bb40f39"

SRCREV_meta="69ebea34250696ebe2d8c87c553480974e56d922"

require linux-hilscher-common.inc
