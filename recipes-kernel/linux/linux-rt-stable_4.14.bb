KBRANCH = "v4.14-netx4000-rt"
KTYPE = "preempt-rt"

# netX4000
LINUX_VERSION = "4.14.40-rt30"
SRCREV_machine="ea27af99293167aebc8785ccace520d176c28c0a"

SRCREV_meta="c5e05f3c61046bf6445adff30d5a03a82677d351"

require linux-hilscher-common.inc
